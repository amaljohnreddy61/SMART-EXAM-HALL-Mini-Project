# Keil uVision project SMART_EXAM_monitoring_sys.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SMART_EXAM_monitoring_sys
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ./SMART_EXAM_monitoring_sys_fixed_1/: adc.c buzzer.c delay.c exam.c interrupt.c keypad.c lcd.c led.c main.c password.c rtc.c sevenseg.c
